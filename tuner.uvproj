# Keil uVision project tuner.uvproj, settings and files
target STM32F1-TUNER (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tuner
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD ARM_MATH_CM3
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F1-TUNER;.\Libraries\DSP_Lib\Include;.\minunit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c lcd_lib.c itoa.c Retarget.c
  group CMSIS
    ./: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_adc.c
  group MDK-ARM
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group DSP-Lib
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/TransformFunctions/: arm_cfft_radix4_init_q15.c arm_cfft_radix4_q15.c arm_dct4_init_q15.c arm_dct4_q15.c arm_rfft_init_q15.c arm_rfft_q15.c
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/CommonTables/: arm_common_tables.c
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/ComplexMathFunctions/: arm_cmplx_mult_cmplx_q15.c
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/BasicMathFunctions/: arm_mult_q15.c arm_shift_q15.c
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/FastMathFunctions/: arm_sin_f32.c
    ./Libraries/DSP_Lib/Source/Cortex-M4-M3/SupportFunctions/: arm_float_to_q15.c
  group MinUnit
    ./minunit/: minunit.c
